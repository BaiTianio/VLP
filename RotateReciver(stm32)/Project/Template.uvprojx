# Keil uVision project Template.uvprojx, settings and files
target RotateVLP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RotateVLP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB;..\SYSTEM;..\User;..\HardWare\ADC;..\HardWare\GPIO;..\HardWare\EXTI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c dma.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group HardWare
    ../HardWare/ADC/: adc.c
    ../HardWare/GPIO/: gpio.c
    ../HardWare/EXTI/: exti.c
